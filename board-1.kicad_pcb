# Repository voxhubio/silvius-btkey-hardware

File README.md:

### Silvius btkey

This is a remotely-controlled USB keyboard, intended for use with the [Silvius
voice recognition system](http://voxhub.io/silvius).

The accompanying firmware and software can be seen in the
`silvius-btkey-bootloader` and `silvius-btkey-firmware` repositories.

### Licensing

The schematics for the btkey are released under the CERN OHL 1.2. See the file
LICENSE for more information.

## KiCad design board-1.kicad_pcb

Parts:
C1: 10uF (low ESR); C_Rect_L7_W2.5_P5
C2: 100nF; C_Rect_L7_W2.5_P5
C3, C4: 100nF (low ESR); C_Rect_L7_W2.5_P5
C5, C6: 33pF; C_Rect_L7_W2.5_P5
C7: 47uF; C_Radial_D5_L6_P2.5
D1: LED; Pin_Header_Straight_1x02
D2: D; Diode_DO-35_SOD27_Horizontal_RM10
P1: CONN_01X03; Pin_Header_Straight_1x03
P2: USB_B_fixed; USB_B
P3: CONN_01X07; Pin_Header_Straight_1x07
P4: CONN_01X05; Pin_Header_Straight_1x05
P5: CONN_01X02; Pin_Header_Straight_1x02
R1: 10K; Resistor_Horizontal_RM10mm
R2: 470; Resistor_Horizontal_RM10mm
R3: 10; Resistor_Horizontal_RM15mm
R4: 330; Resistor_Horizontal_RM10mm
U1: MCP1700; TO-92_Inline_Wide
U2: PIC32MX2XX; DIP-28__300_ELL
Y1: 24MHz; Crystal_HC49-U_Vertical

Connections:
+3V3: C3.1, C4.1, C7.1, P1.3, P3.1, P4.4, R1.1, R3.2, U1.3 (VOUT), U2.13 (VDD), U2.23 (VUSB3V3)
/RST: P3.6, R2.1, U2.1 (MCLR#)
/StatusLED: R4.2, U2.2 (RA0)
/TCK: P3.4, U2.17 (RB8)
/TDI: P3.3, U2.16 (RB7)
/TDO: P3.5, U2.18 (RB9)
/TMS: P3.2, U2.14 (RB5)
/UART_RCV: P5.1, U2.3 (RA1)
/UART_SND: P5.2, U2.4 (RB0)
/USB_N: P2.1, U2.22 (RB11)
/USB_P: P2.4, U2.21 (RB10)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D1.1 (K), P2.3, P3.7, P4.3, U1.1 (GND), U2.8 (VSS), U2.19 (VSS2), U2.27 (AVSS)
unnamed: C1.1, U2.20 (VCAP)
unnamed: C2.1, R1.2, R2.2
unnamed: C5.1, U2.9 (RA2), Y1.1
unnamed: C6.1, U2.10 (RA3), Y1.2
unnamed: D1.2 (A), R4.1
unnamed: D2.1 (K), U1.2 (VIN), U2.15 (VBUS)
unnamed: D2.2 (A), P2.2
unnamed: P1.1, U2.5 (RB1)
unnamed: P1.2, U2.6 (RB2)
unnamed: P4.1, U2.26 (RB15)
unnamed: P4.2, U2.24 (RB13)
unnamed: P4.5, U2.25 (RB14)
unnamed: R3.1, U2.28 (AVDD)

Board: 2 copper layers, 50.0 x 38.1 mm, 22 parts (1 on the bottom side), 25 nets.

Other parts of the board:
oshw: oshw-small-2

## Commit log

2016-01-31 Revision r1 submitted to fab.
2016-02-05 Added diode between USB power in and voltage regulator.
    Also added OSHW logo.
2016-02-05 Add forgotten footprint.
2016-02-05 Add forgotten file.
2016-02-05 Added README and LICENSE files.
2016-02-06 Made more compliant with OHL requirements.
2016-05-22 Revision 3.
2016-05-23 Updated capacitor footprints.
2016-05-23 Updated revision 3.
2016-05-23 Move some silkscreen labels.
2016-07-18 Changes for r4.
    Major change: a board that fits in a 5cmx5cm square.

Notices in the files:
board-1.kicad_pcb:
Licensed under CERN OHL v.1.2
